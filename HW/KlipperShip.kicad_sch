File: HW/KlipperShip.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: USB hub, connector, load switch
